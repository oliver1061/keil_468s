# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NF-468S_V1_1_20201231 +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\fwlib\inc;.\user;.\include;.\user\gpio_config;.\user\select;.\user\delay;.\user\cd4017;.\user\adc;.\user\time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: startup_stm32f030.s
  group fwlib
    ./fwlib/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_dma.c
  group user
    ./user/: main.c stm32f0xx_it.c system_stm32f0xx.c
    ./user/select/: select.c
    ./user/delay/: delay.c
    ./user/cd4017/: cd4017.c
    ./user/adc/: adc.c
    ./user/time/: time.c
    ./user/gpio_config/: gpioconfig.c
